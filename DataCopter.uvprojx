# Keil uVision project DataCopter.uvprojx, settings and files
target DataCopter (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: DataCopter +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Copter
    ./Copter/: DataCopter.cpp
  group ::Device
    RTE/Device/STM32F405RG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.0
